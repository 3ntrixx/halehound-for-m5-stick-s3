#pragma once
#include <stdint.h>
#include <stddef.h>
#include <string.h>

// Wire-format facts from dave-code-ruiz/elkbledom models.json and
// madhead/saberlight protocols/Triones/protocol.md (see SKELETONKEY_PORT.md).
// No radio or Arduino dependencies: exercised by host packet-vector tests.
namespace SkeletonKeyProtocol {
enum Action : uint8_t { PowerOn, PowerOff, Red, Green, Blue, White, Color, Brightness };
static constexpr size_t PacketSize = 9;
static constexpr uint16_t R = 256, G = 257, B = 258, Level = 259;
struct Profile {
    const char *name;
    uint16_t service, characteristic, handle; // handle=0 means any
    uint8_t powerLength, colorLength, brightnessLength;
    uint16_t on[9], off[9], color[9], brightness[9];
};
static const Profile Profiles[] = {
    {"ELK-BTC", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x00, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x00, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x0a, 0xef}, {0x7e, 0x00, 0x01, Level, 0x00, 0x00, 0x00, 0x00, 0xef}},
    {"ELK-BLEDOB", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x07, 0x04, 0xff, 0x00, 0x01, 0x02, 0x01, 0xef}, {0x7e, 0x07, 0x04, 0x00, 0x00, 0x00, 0x02, 0x01, 0xef},
        {0x7e, 0x07, 0x05, 0x03, R, G, B, 0x0a, 0xef}, {0x7e, 0x04, 0x01, Level, 0x01, 0xff, 0x02, 0x01, 0xef}},
    {"ELK-BLEDDM", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x04, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x04, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0x00, 0xff, 0x00, 0xef}},
    {"ELK-BLEDOM0E", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x07, 0x04, 0xff, 0x00, 0x01, 0x02, 0x01, 0xef}, {0x7e, 0x07, 0x04, 0x00, 0x00, 0x00, 0x02, 0x01, 0xef},
        {0x7e, 0x07, 0x05, 0x03, R, G, B, 0x0a, 0xef}, {0x7e, 0x04, 0x01, Level, 0x01, 0xff, 0x02, 0x01, 0xef}},
    {"ELK-BLEDOM", 0xfff0, 0xfff3, 13, 9, 9, 9,
        {0x7e, 0x04, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x04, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x07, 0x05, 0x03, R, G, B, 0x0a, 0xef}, {0x7e, 0x04, 0x01, Level, 0x01, 0xff, 0x02, 0x01, 0xef}},
    {"ELK-BLEDOM", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x00, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x00, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x00, 0x01, Level, 0xff, 0x00, 0xff, 0x00, 0xef}},
    {"ELK-BLE", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x00, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x00, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0x00, 0xff, 0x00, 0xef}},
    {"LEDBLE", 0xffe0, 0xffe1, 0, 9, 9, 9,
        {0x7e, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0xef}, {0x7e, 0x00, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0x00, 0xff, 0x00, 0xef}},
    {"LED-", 0xffe0, 0xffe1, 0, 9, 9, 9,
        {0x7e, 0x04, 0x04, 0x01, 0xff, 0xff, 0xff, 0x00, 0xef}, {0x7e, 0x04, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0xef},
        {0x7e, 0x07, 0x05, 0x03, R, B, G, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0xff, 0xff, 0x00, 0xef}},
    {"JACKYLED", 0xffe0, 0xffe1, 0, 9, 9, 9,
        {0x7e, 0x04, 0x04, 0x01, 0xff, 0xff, 0xff, 0x00, 0xef}, {0x7e, 0x04, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0xef},
        {0x7e, 0x07, 0x05, 0x03, R, B, G, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0xff, 0xff, 0x00, 0xef}},
    {"XROCKER", 0xffe0, 0xffe1, 0, 9, 9, 9,
        {0x7b, 0xff, 0x04, 0x01, 0xff, 0xff, 0xff, 0xff, 0xbf}, {0x7b, 0xff, 0x04, 0x00, 0xff, 0xff, 0xff, 0xff, 0xbf},
        {0x7b, 0xff, 0x05, 0x03, R, G, B, 0xff, 0xbf}, {0x7b, 0x04, 0x01, Level, 0xff, 0xff, 0xff, 0xff, 0xbf}},
    {"MELK-OG10", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x07, 0x04, 0xff, 0x00, 0x01, 0x02, 0x01, 0xef}, {0x7e, 0x07, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0x00, 0xff, 0x00, 0xef}},
    {"MELK-OF10", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x04, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x04, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0x01, 0xff, 0xff, 0x00, 0xef}},
    {"MELK-OC10", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x04, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x04, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0x01, 0xff, 0xff, 0x00, 0xef}},
    {"MELK-OA10", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x04, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x04, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0x01, 0xff, 0xff, 0x00, 0xef}},
    {"MELK-OA21", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x04, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x04, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0x01, 0xff, 0xff, 0x00, 0xef}},
    {"MELK", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0xef}, {0x7e, 0x00, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0x00, 0xff, 0x00, 0xef}},
    {"ELK-BULB2", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x00, 0x04, 0xf0, 0x00, 0x01, 0xff, 0x00, 0xef}, {0x7e, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0x00, 0xff, 0x00, 0xef}},
    {"ELK-BULB", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0xef}, {0x7e, 0x00, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0x00, 0xff, 0x00, 0xef}},
    {"ELK-LAMPL", 0xfff0, 0xfff3, 0, 9, 9, 9,
        {0x7e, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0xef}, {0x7e, 0x00, 0x04, 0x00, 0x00, 0x00, 0xff, 0x00, 0xef},
        {0x7e, 0x00, 0x05, 0x03, R, G, B, 0x00, 0xef}, {0x7e, 0x04, 0x01, Level, 0xff, 0x00, 0xff, 0x00, 0xef}},
    {"Triones", 0xffd5, 0xffd9, 0, 3, 7, 0,
        {0xcc, 0x23, 0x33}, {0xcc, 0x24, 0x33},
        {0x56, R, G, B, 0, 0xf0, 0xaa}, {}},
};
static constexpr int ProfileCount = sizeof(Profiles) / sizeof(Profiles[0]);
inline const Profile *profile(int index) {
    return index >= 0 && index < ProfileCount ? &Profiles[index] : nullptr;
}
inline bool matchesName(const char *name, const char *model) {
    if (!name || !model) return false;
    while (*model) {
        char a = *name++, b = *model++;
        if (a >= 'a' && a <= 'z') a -= 32;
        if (b >= 'a' && b <= 'z') b -= 32;
        if (a != b) return false;
    }
    // Accept an exact match, or any trailing suffix made of separators
    // and/or alphanumerics — these generic BLE light controllers commonly
    // append a per-unit ID straight onto the base name with no separator
    // at all (observed in the field: "ELK-BLEDOM08" for a device whose
    // matching profile is named "ELK-BLEDOM").
    while (*name) {
        char c = *name++;
        bool ok = (c >= '0' && c <= '9') || (c >= 'A' && c <= 'Z') || (c >= 'a' && c <= 'z') ||
                  c == '-' || c == '_' || c == ' ';
        if (!ok) return false;
    }
    return true;
}
inline bool endpoint(int index, uint16_t service, uint16_t characteristic) {
    const Profile *p = profile(index);
    return p && p->service == service && p->characteristic == characteristic;
}
inline int detect(const char *name, uint16_t service, uint16_t characteristic, uint16_t handle) {
    int best = -1;
    size_t bestScore = 0;
    for (int i = 0; i < ProfileCount; ++i) {
        const Profile &p = Profiles[i];
        if (!endpoint(i, service, characteristic) || !matchesName(name, p.name) ||
            (p.handle && p.handle != handle)) continue;
        size_t score = strlen(p.name) * 2 + (p.handle ? 1 : 0);
        if (score > bestScore) { best = i; bestScore = score; }
    }
    return best;
}
// Level is 0..100. RGB white deliberately uses all three color channels.
inline size_t packet(int index, Action action, uint8_t r, uint8_t g, uint8_t b,
                     uint8_t level, uint8_t *out, size_t capacity) {
    const Profile *p = profile(index);
    if (!p || !out || action > Brightness || level > 100) return 0;
    const uint16_t *data = p->color;
    size_t len = p->colorLength;
    if (action == PowerOn || action == PowerOff) {
        data = action == PowerOn ? p->on : p->off; len = p->powerLength;
    } else if (action == Brightness) {
        data = p->brightness; len = p->brightnessLength;
    } else if (action != Color) {
        r = (action == Red || action == White) ? 255 : 0;
        g = (action == Green || action == White) ? 255 : 0;
        b = (action == Blue || action == White) ? 255 : 0;
    }
    if (!len || len > capacity) return 0;
    for (size_t i = 0; i < len; ++i) {
        uint16_t v = data[i];
        out[i] = v == R ? r : v == G ? g : v == B ? b : v == Level ? level : uint8_t(v);
    }
    return len;
}
} // namespace SkeletonKeyProtocol
